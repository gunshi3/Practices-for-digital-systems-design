# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W1K16S STC
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
