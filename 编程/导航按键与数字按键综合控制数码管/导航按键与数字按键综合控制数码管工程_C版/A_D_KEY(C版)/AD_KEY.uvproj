# Keil uVision project AD_KEY.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: AD_KEY +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AD_KEY.c STC15F2K60S2.H
